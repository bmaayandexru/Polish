# Keil uVision project saw.uvproj, settings and files
target saw (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: saw +hex
  c flags: Optim=4
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group system
    ./CM3/CoreSupport/: core_cm3.c
    ./CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Drivers
    ./Drivers/source/: lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_timer.c
    ./Drivers/: sbl_iap.c
  group UCNC
    ./Main/: Modbus.c FS.c msg.c bFS.c
    ./UCNC/: ti.c Timers.c UART.c Tools.c Flash.c StaticPins.c VirtualPins.c Nextion.c
  group Main
    ./Main/: queue.c u0packets.c u1packets.c Main.c Handlers.c Motors.c FreqInvr.c regs.c VPFrz.c KeyPad.c Motor_X.c Motor_Y.c Motor_Z.c pwm.c
